PR = "r1"
FILESEXTRAPATHS:prepend := "${THISDIR}/${P}:"
